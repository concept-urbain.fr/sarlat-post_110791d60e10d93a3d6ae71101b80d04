Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Sarlat poteler amovible.IFC
Time: 2020-07-02T06:19:01
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: SARL-POT-AS-002_Default
In: Default Storey
Material: S235

# IfcBuildingElementProxy: NAST-POT-110-AMO-004_Default
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: SARL-POT-AMO-001-01_Default
In: Default Storey
Material: S235
PSet_Mass_Property - Mass Measure: 9.95234; Area Measure: 0.353159; Volume Measure: 0.00129034

# IfcBuildingElementProxy: SARL-POT-AS-003_Default
In: Default Storey
Material: 6060
