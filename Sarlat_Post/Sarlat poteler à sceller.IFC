Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Sarlat poteler à sceller.IFC
Time: 2020-07-02T06:19:20
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: SARL-POT-AS-001-01_Default
In: Default Storey
Material: S235
PSet_Mass_Property - Mass Measure: 10.8259; Area Measure: 0.402831; Volume Measure: 0.00140209

# IfcBeam: SARL-POT-AS-002_Default
In: Default Storey
Material: S235

# IfcBeam: SARL-POT-AS-003_Default
In: Default Storey
Material: 6060
